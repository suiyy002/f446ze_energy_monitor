<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\f446ze_energy_monitor.ewp</path>
  </project>
  <batchBuild />
</workspace>
